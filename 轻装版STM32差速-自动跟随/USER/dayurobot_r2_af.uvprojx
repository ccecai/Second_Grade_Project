# Keil uVision project dayurobot_r2_af.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dayurobot_r2 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\OLED;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\EXTI;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\ENCODER;..\HARDWARE\control;..\HARDWARE\USB;..\HARDWARE\LED;..\HARDWARE\PWM;..\HARDWARE\MOTOR;..\HARDWARE\PWM;..\HARDWARE\ADC;..\HARDWARE\USART3;..\HARDWARE\KEY;..\HARDWARE\UltrasonicWave;..\HARDWARE\TIMER;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.3.0\CMSIS\Include;..\SYSTEM\sys;..\HARDWARE\PS2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c main.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c core_cm3.c
    ../SYSTEM/usart/: usart.c
  group HAREWARE
    ../HARDWARE/LED/: LED.C
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/control/: control.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/USART3/: usart3.c usart3.h
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/UltrasonicWave/: UltrasonicWave.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/PS2/: pstwo.c
    ../HARDWARE/OLED/: oled.c
  group CORE
    ../CORE/: startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
